# Keil uVision project ohdb.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F206 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: OHDB2_A2D +hex
  c flags: Optimize=3 SizeSpeed=1
  c include: ..\SharedModules\SysDef, AD\, Timer\, SPI\, Version\
  group Source Group 1
    ./AD/: addrv.c
    ./Main/: A2DMain.C
    ./SPI/: SpiDrv.c
    ./Timer/: TimerDrv.C
  group Header Files
    ./SPI/: SpiDrv.h
    ./AD/: addrv.h
    ./Timer/: TimerDrv.H
    ./Version/: Version.h
