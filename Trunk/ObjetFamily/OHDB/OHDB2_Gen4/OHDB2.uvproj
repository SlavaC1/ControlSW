# Keil uVision project OHDB2.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: OHDB2 +hex
  c flags: SizeSpeed=1
  c define: C8051F123_CPU
  c include: ..\SharedModules\SysDef, SPI\, ..\SharedModules\RingBuffer, UART\, A2D\, ..\SharedModules\Xilinx, ..\SharedModules\EdenProtocol, Timer\, Potentiometer\, HeaterControl\, E2PROM\, MsgDecode\, ..\SharedModules\Utilities, ..\SharedModules\Scheduler, ..\SharedModules\Roller, Potentiometer\,  PrintDriver\, Sensors\, HeadData\, Utils\, Watchdog\, Version\, Actuators\, D2A\, Comparator\, Bumper\, Fans\
  group Source Group 1
    ../SharedModules/RingBuffer/: RingBuff.C
    ../SharedModules/Roller/: Roller.c
    ../SharedModules/Scheduler/: MiniScheduler.c
    ../SharedModules/Utilities/: ByteOrder.c
    ../SharedModules/Xilinx/: XilinxInterface.c
    ./Main/: OhdbMain.C
    ./Timer/: TimerDrv.C
    ./Uart/: UartDrv.c
    ./SPI/: SpiDrv.c
    ./A2D/: A2D.c Spi_A2D.c SpiExtA2D.c
    ./HeadData/: HeadData.c
    ./HeaterControl/: HeaterControl.c
    ./PrintDriver/: PrintDriver.c
    ./D2A/: D2A.c
    ./E2PROM/: E2PROMInterface.c
    ./Utils/: Utils.c
    ./Watchdog/: Watchdog.c
    ./Comparator/: Comparator.c
    ./Bumper/: Bumper.c
    ./MsgDecode/: MsgDecodeOHDB.c
    ./Actuators/: ActuatorsOHDB.c
    ./Sensors/: SensorsOHDB.c HeadsVoltageReader.c
    ./Potentiometer/: PotentiometerOHDB.c
    ../SharedModules/EdenProtocol/: EdenProtocolOHDB.c
    ./Fans/: Fans.c
  group Header Files
    ../SharedModules/RingBuffer/: RingBuff.H
    ../SharedModules/Roller/: Roller.h
    ../SharedModules/Scheduler/: MiniScheduler.h
    ../SharedModules/SysDef/: Define.h c8051F020.h
    ../SharedModules/Utilities/: ByteOrder.h
    ../SharedModules/Xilinx/: XilinxInterface.h
    ./Timer/: TimerDrv.H
    ./Uart/: UartDrv.h
    ./SPI/: SpiDrv.h
    ./A2D/: A2D.h Spi_A2D.h SpiExtA2D.h
    ./HeaterControl/: HeaterControl.h
    ./PrintDriver/: PrintDriver.h
    ./D2A/: D2A.h
    ./E2PROM/: E2PROMInterface.h
    ./Utils/: Utils.h
    ./HeadData/: HeadData.h
    ./Watchdog/: Watchdog.h
    ./Version/: Version.h
    ./Comparator/: Comparator.h
    ./Bumper/: Bumper.h
    ./MsgDecode/: MsgDecodeOHDB.h
    ./Actuators/: ActuatorsOHDB.h
    ./Sensors/: SensorsOHDB.h HeadsVoltageReader.h
    ./Potentiometer/: PotentiometerOHDB.h
    ../SharedModules/EdenProtocol/: EdenProtocolOHDB.h
