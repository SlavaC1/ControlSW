# Keil uVision project OCB4Sim.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F131 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: OCBSim +hex
  c flags: Optimize=3
  c define: OCB_SIMULATOR,OBJET_MACHINE,OCB2, SIM_GEN4
  c include: ..\Sources\SysDef\;..\Sources\A2D;..\Sources\RingBuffer;..\Sources\Scheduler;..\Sources\Utils;..\Sources\EdenProtocol;..\Sources\Main;..\Sources\TimerSim;..\Sources\Version;..\Sources\MsgDecode;..\Sources\Comparator;..\Sources\I2C;..\Sources\Actuators;..\Sources\Sensors;..\Sources\Door;..\Sources\UVLamps;..\Sources\Power;..\Sources\LiquidTanks;..\Sources\Purge;..\Sources\HeadsFilling;..\Sources\Tray;..\Sources\Potentiometer;..\Sources\D2A;..\Sources\Average;..\..\..\OHDB\SharedModules\Xilinx;..\..\..\OHDB\OHDB2_Gen4\SPI;..\..\..\OHDB\OHDB2_Gen4\HeaterControl;..\..\..\OHDB\OHDB2_Gen4\Sensors;..\..\..\OHDB\OHDB2_Gen4\Actuators;..\..\..\OHDB\SharedModules\Roller;..\..\..\OHDB\OHDB2_Gen4\MsgDecode;..\..\..\OHDB\OHDB2_Gen4\PrintDriver;..\..\..\OHDB\OHDB2_Gen4\Watchdog;..\..\..\OHDB\OHDB2_Gen4\Bumper;..\..\..\OHDB\OHDB2_Gen4\HeadData;..\..\..\OHDB\OHDB2_Gen4\E2PROM;..\Sources\SignalTower;..\Sources\UartSim;..\Sources\MSC;..\..\..\OHDB\OHDB2_Gen4\Fans
  group Source Group 1
    ../Sources/Scheduler/: MiniScheduler.c
    ../Sources/RingBuffer/: RingBuff.C
    ../Sources/EdenProtocol/: EdenProtocol.c
    ../Sources/Utils/: ByteOrder.c Utils.c
    ../Sources/Main/: OcbMain.c
    ../Sources/MsgDecode/: MsgDecode.c
    ../Sources/Actuators/: Actuators.c
    ../Sources/Sensors/: Sensors.c
    ../Sources/Door/: Door.c
    ../Sources/UVLamps/: UVLamps.c
    ../Sources/Power/: Power.c
    ../Sources/LiquidTanks/: LiquidTanks.c
    ../Sources/Purge/: PURGE.C
    ../Sources/HeadsFilling/: HeadsFilling.c
    ../Sources/Tray/: Tray.c
    ../Sources/Average/: Average.c
    ../Sources/A2D/: A2DSim.c Spi_A2DSim.c
    ../../../OHDB/OHDB2_Gen4/HeaterControl/: HeaterControl.c
    ../../../OHDB/SharedModules/Xilinx/: XilinxInterface.c
    ../../../OHDB/OHDB2_Gen4/SPI/: SpiDrvOHDBSim.c
    ../../../OHDB/SharedModules/Roller/: Roller.c
    ../../../OHDB/OHDB2_Gen4/Actuators/: ActuatorsOHDB.c
    ../../../OHDB/OHDB2_Gen4/MsgDecode/: MsgDecodeOHDB.c
    ../../../OHDB/OHDB2_Gen4/PrintDriver/: PrintDriver.c
    ../../../OHDB/OHDB2_Gen4/Sensors/: SensorsOHDB.c HeadsVoltageReader.c
    ../../../OHDB/OHDB2_Gen4/Watchdog/: Watchdog.c
    ../../../OHDB/OHDB2_Gen4/Bumper/: Bumper.c
    ../../../OHDB/OHDB2_Gen4/HeadData/: HeadData.c
    ../../../OHDB/OHDB2_Gen4/E2PROM/: E2PROMInterface.c
    ../Sources/Potentiometer/: Potentiometer.c
    ../Sources/UartSim/: UartDrv.c
    ../Sources/EXTMemSim/: EXTMem.c
    ../Sources/TimerSim/: TimerDrv.C
    ../Sources/D2A/: D2ASim.c
    ../Sources/Comparator/: ComparatorSim.c
    ../Sources/I2C/: I2C_DRVSim.c
    ../Sources/SignalTower/: SignalTower.c
    ../Sources/: L51_BANK.A51
    ../../../OHDB/OHDB2_Gen4/Potentiometer/: PotentiometerOHDB.c
    ../Sources/MSC/: MSCInterface.c
    ../../../OHDB/OHDB2_Gen4/Fans/: Fans.c
  group Header Files
    ../Sources/A2D/: Spi_A2D.h A2D.h
    ../Sources/RingBuffer/: RingBuff.H
    ../Sources/Scheduler/: MiniScheduler.h
    ../Sources/EdenProtocol/: EdenProtocol.h
    ../Sources/Utils/: ByteOrder.h
    ../Sources/MsgDecode/: MsgDecode.h MsgExtern.h
    ../Sources/SysDef/: Define.h c8051f120.h
    ../Sources/Version/: Version.h
    ../Sources/Comparator/: Comparator.h
    ../Sources/Actuators/: Actuators.h
    ../Sources/Sensors/: Sensors.h
    ../Sources/Door/: Door.h
    ../Sources/UVLamps/: UVLamps.h
    ../Sources/Power/: Power.h
    ../Sources/LiquidTanks/: LiquidTanks.h
    ../Sources/Purge/: PURGE.H
    ../Sources/HeadsFilling/: HeadsFilling.h
    ../Sources/Tray/: Tray.h
    ../Sources/D2A/: D2A.h
    ../Sources/Average/: Average.h
    ../../../OHDB/OHDB2_Gen4/HeaterControl/: HeaterControl.h
    ../../../OHDB/SharedModules/Xilinx/: XilinxInterface.h
    ../../../OHDB/SharedModules/Roller/: Roller.h
    ../../../OHDB/OHDB2_Gen4/Actuators/: ActuatorsOHDB.h
    ../../../OHDB/OHDB2_Gen4/MsgDecode/: MsgDecodeOHDB.h
    ../../../OHDB/OHDB2_Gen4/PrintDriver/: PrintDriver.h
    ../../../OHDB/OHDB2_Gen4/Sensors/: SensorsOHDB.h HeadsVoltageReader.h
    ../../../OHDB/OHDB2_Gen4/Watchdog/: Watchdog.h
    ../../../OHDB/OHDB2_Gen4/Bumper/: Bumper.h
    ../../../OHDB/OHDB2_Gen4/HeadData/: HeadData.h
    ../../../OHDB/OHDB2_Gen4/E2PROM/: E2PROMInterface.h
    ../Sources/Potentiometer/: Potentiometer.h
    ../Sources/UartSim/: UartDrv.h
    ../Sources/EXTMemSim/: EXTMem.h
    ../Sources/TimerSim/: TimerDrv.H
    ../Sources/I2C/: I2C_DRV.h
    ../Sources/ExtMemAddSim/: ExtMemAddSim.h
    ../Sources/SignalTower/: SignalTower.h
    ../Sources/MSC/: MSCInterface.h
    ../../../OHDB/OHDB2_Gen4/Potentiometer/: PotentiometerOHDB.h
    ../../../OHDB/OHDB2_Gen4/SPI/: SpiDrv.h
    ../../../OHDB/OHDB2_Gen4/Fans/: Fans.h
