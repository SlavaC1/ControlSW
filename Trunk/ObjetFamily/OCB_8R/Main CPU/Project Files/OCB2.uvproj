# Keil uVision project OCB2.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F122 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: OCB2 +hex
  c flags: SizeSpeed=1
  c define: OBJET_MACHINE,OCB2,FAST_WEIGHT_SAMPLE_TIME
  c include: ..\Sources\SysDef\;..\Sources\Timer;..\Sources\UART;..\Sources\A2D;..\Sources\RingBuffer;..\Sources\SPI;..\Sources\Scheduler;..\Sources\Utils;..\Sources\EdenProtocol;..\Sources\Main;..\Sources\Timer;..\Sources\Version;..\Sources\MsgDecode;..\Sources\Comparator;..\Sources\I2C;..\Sources\Actuators;..\Sources\Sensors;..\Sources\Door;..\Sources\UVLamps;..\Sources\Power;..\Sources\LiquidTanks;..\Sources\Purge;..\Sources\HeadsFilling;..\Sources\Tray;..\Sources\Potentiometer;..\Sources\D2A;..\Sources\Average;..\Sources\SignalTower;..\Sources\MSC
  group Source Group 1
    ../Sources/A2D/: A2D.c Spi_A2D.c
    ../Sources/SPI/: SpiDrv.c
    ../Sources/Uart/: UartDrv.c
    ../Sources/Scheduler/: MiniScheduler.c
    ../Sources/RingBuffer/: RingBuff.C
    ../Sources/EdenProtocol/: EdenProtocol.c
    ../Sources/Utils/: ByteOrder.c
    ../Sources/Timer/: TimerDrv.C
    ../Sources/Main/: OcbMain.c
    ../Sources/MsgDecode/: MsgDecode.c
    ../Sources/Comparator/: Comparator.c
    ../Sources/Actuators/: Actuators.c
    ../Sources/Sensors/: Sensors.c
    ../Sources/Door/: Door.c
    ../Sources/UVLamps/: UVLamps.c
    ../Sources/Power/: Power.c
    ../Sources/LiquidTanks/: LiquidTanks.c
    ../Sources/Purge/: PURGE.C
    ../Sources/HeadsFilling/: HeadsFilling.c
    ../Sources/Tray/: Tray.c
    ../Sources/Potentiometer/: Potentiometer.c
    ../Sources/D2A/: D2A.c
    ../Sources/Average/: Average.c
    ../Sources/I2C/: I2C_DRV.c
    ../Sources/SignalTower/: SignalTower.c
    ../Sources/MSC/: MSCInterface.c
  group Header Files
    ../Sources/RingBuffer/: RingBuff.H
    ../Sources/A2D/: A2D.h Spi_A2D.h
    ../Sources/Uart/: UartDrv.h
    ../Sources/SPI/: SpiDrv.h
    ../Sources/Scheduler/: MiniScheduler.h
    ../Sources/EdenProtocol/: EdenProtocol.h
    ../Sources/Utils/: ByteOrder.h
    ../Sources/Timer/: TimerDrv.H
    ../Sources/MsgDecode/: MsgDecode.h MsgExtern.h
    ../Sources/SysDef/: Define.h c8051F020.h
    ../Sources/Version/: Version.h
    ../Sources/Comparator/: Comparator.h
    ../Sources/Actuators/: Actuators.h
    ../Sources/Sensors/: Sensors.h
    ../Sources/Door/: Door.h
    ../Sources/UVLamps/: UVLamps.h
    ../Sources/Power/: Power.h
    ../Sources/LiquidTanks/: LiquidTanks.h
    ../Sources/Purge/: PURGE.H
    ../Sources/HeadsFilling/: HeadsFilling.h
    ../Sources/Tray/: Tray.h
    ../Sources/Potentiometer/: Potentiometer.h
    ../Sources/D2A/: D2A.h
    ../Sources/Average/: Average.h
    ../Sources/SignalTower/: SignalTower.h
    ../Sources/MSC/: MSCInterface.h
