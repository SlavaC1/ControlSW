# Keil uVision project OCB4Sim.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F131 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: OCBSim +hex
  c flags: Optimize=1
  c define: OCB_SIMULATOR,OBJET_MACHINE,OCB2,LIMIT_TO_DM2,DUAL_WASTE,THREE_DOORS
  c include: ..\Sources\SysDef\;..\Sources\TimerSim;..\Sources\UartSim;..\Sources\A2D;..\Sources\RingBuffer;..\Sources\Scheduler;..\Sources\Utils;..\Sources\EdenProtocol;..\Sources\Main;..\Sources\Timer;..\Sources\Version;..\Sources\MsgDecode;..\Sources\Comparator;..\Sources\I2C;..\Sources\Actuators;..\Sources\Sensors;..\Sources\Door;..\Sources\UVLamps;..\Sources\Power;..\Sources\LiquidTanks;..\Sources\Purge;..\Sources\HeadsFilling;..\Sources\Tray;..\Sources\Potentiometer;..\Sources\D2A;..\Sources\Average;..\..\..\OHDB\SharedModules\Xilinx;..\..\..\OHDB\OHDB_F023_Processor\SPI;..\..\..\OHDB\OHDB_F023_Processor\HeaterControl;..\..\..\OHDB\OHDB_F023_Processor\Sensors;..\..\..\OHDB\OHDB_F023_Processor\Actuators;..\..\..\OHDB\SharedModules\Roller;..\..\..\OHDB\OHDB_F023_Processor\MsgDecode;..\..\..\OHDB\OHDB_F023_Processor\PrintDriver;..\..\..\OHDB\OHDB_F023_Processor\Watchdog;..\..\..\OHDB\OHDB_F023_Processor\Bumper;..\..\..\OHDB\OHDB_F023_Processor\HeadData;..\..\..\OHDB\OHDB_F023_Processor\E2PROM;..\Sources\SignalTower
  group Source Group 1
    ../Sources/Scheduler/: MiniScheduler.c
    ../Sources/RingBuffer/: RingBuff.C
    ../Sources/EdenProtocol/: EdenProtocol.c
    ../Sources/Utils/: ByteOrder.c Utils.c
    ../Sources/Main/: OcbMain.c
    ../Sources/MsgDecode/: MsgDecode.c
    ../Sources/Actuators/: Actuators.c
    ../Sources/Sensors/: Sensors.c
    ../Sources/Door/: Door.c
    ../Sources/UVLamps/: UVLamps.c
    ../Sources/Power/: Power.c
    ../../../OHDB/OHDB_F023_Processor/Potentiometer/: PotentiometerOHDB.c
    ../Sources/LiquidTanks/: LiquidTanks.c
    ../Sources/Purge/: PURGE.C
    ../Sources/HeadsFilling/: HeadsFilling.c
    ../Sources/Tray/: Tray.c
    ../Sources/Average/: Average.c
    ../Sources/A2D/: A2DSim.c Spi_A2DSim.c
    ../../../OHDB/OHDB_F023_Processor/HeaterControl/: HeaterControl.c
    ../../../OHDB/SharedModules/Xilinx/: XilinxInterface.c
    ../../../OHDB/OHDB_F023_Processor/SPI/: SpiDrvOHDBSim.c SpiDrv.h
    ../../../OHDB/SharedModules/Roller/: Roller.c
    ../../../OHDB/OHDB_F023_Processor/Actuators/: ActuatorsOHDB.c
    ../../../OHDB/OHDB_F023_Processor/MsgDecode/: MsgDecodeOHDB.c
    ../../../OHDB/OHDB_F023_Processor/PrintDriver/: PrintDriver.c
    ../../../OHDB/OHDB_F023_Processor/Sensors/: SensorsOHDB.c
    ../../../OHDB/OHDB_F023_Processor/Watchdog/: Watchdog.c
    ../../../OHDB/OHDB_F023_Processor/Bumper/: Bumper.c
    ../../../OHDB/OHDB_F023_Processor/HeadData/: HeadData.c
    ../../../OHDB/OHDB_F023_Processor/E2PROM/: E2PROMInterface.c
    ../Sources/Potentiometer/: Potentiometer.c
    ../Sources/UartSim/: UartDrv.c
    ../Sources/EXTMemSim/: EXTMem.c
    ../Sources/TimerSim/: TimerDrv.C
    ../Sources/D2A/: D2ASim.c
    ../Sources/Comparator/: ComparatorSim.c
    ../Sources/I2C/: I2C_DRVSim.c
    ../Sources/SignalTower/: SignalTower.c
    ../Sources/: L51_BANK.A51
  group Header Files
    ../Sources/A2D/: Spi_A2D.h
    ../Sources/RingBuffer/: RingBuff.H
    ../Sources/Scheduler/: MiniScheduler.h
    ../Sources/EdenProtocol/: EdenProtocol.h
    ../Sources/Utils/: ByteOrder.h
    ../Sources/MsgDecode/: MsgDecode.h MsgExtern.h
    ../Sources/SysDef/: Define.h c8051f120.h
    ../Sources/Version/: Version.h
    ../Sources/Comparator/: Comparator.h
    ../Sources/Actuators/: Actuators.h
    ../Sources/Sensors/: Sensors.h
    ../Sources/Door/: Door.h
    ../Sources/UVLamps/: UVLamps.h
    ../Sources/Power/: Power.h
    ../Sources/LiquidTanks/: LiquidTanks.h
    ../Sources/Purge/: PURGE.H
    ../Sources/HeadsFilling/: HeadsFilling.h
    ../Sources/Tray/: Tray.h
    ../Sources/D2A/: D2A.h
    ../Sources/Average/: Average.h
    ../../../OHDB/OHDB_F023_Processor/HeaterControl/: HeaterControl.h
    ../../../OHDB/SharedModules/Xilinx/: XilinxInterface.h
    ../../../OHDB/SharedModules/Roller/: Roller.h
    ../../../OHDB/OHDB_F023_Processor/Actuators/: ActuatorsOHDB.h
    ../../../OHDB/OHDB_F023_Processor/MsgDecode/: MsgDecodeOHDB.h
    ../../../OHDB/OHDB_F023_Processor/PrintDriver/: PrintDriver.h
    ../../../OHDB/OHDB_F023_Processor/Sensors/: SensorsOHDB.h
    ../../../OHDB/OHDB_F023_Processor/Watchdog/: Watchdog.h
    ../../../OHDB/OHDB_F023_Processor/Bumper/: Bumper.h
    ../../../OHDB/OHDB_F023_Processor/HeadData/: HeadData.h
    ../../../OHDB/OHDB_F023_Processor/E2PROM/: E2PROMInterface.h
    ../Sources/Potentiometer/: Potentiometer.h
    ../../../OHDB/OHDB_F023_Processor/Potentiometer/: PotentiometerOHDB.h
    ../Sources/UartSim/: UartDrv.h
    ../Sources/EXTMemSim/: EXTMem.h
    ../Sources/TimerSim/: TimerDrv.H
    ../Sources/I2C/: I2C_DRV.h
    ../Sources/ExtMemAddSim/: ExtMemAddSim.h
    ../Sources/SignalTower/: SignalTower.h
